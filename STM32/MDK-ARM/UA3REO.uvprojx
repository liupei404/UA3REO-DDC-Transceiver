# Keil uVision project UA3REO.uvprojx, settings and files
target UA3REO (6120000::V6.12::.\ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: UA3REO +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4
  c include: ../Inc;                                                                                                 ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                                                                 ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                                                                 ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                                                                                 ../Drivers/CMSIS/Include;                                                                                                 ..\USBDevice;                                                                                                 ..\Src;                                                                                                 ..\Src\LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: UA3REO\UA3REO.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: agc.c agc.h audio_processor.c audio_processor.h audio_filters.c audio_filters.h bands.c bands.h bootloader.c bootloader.h cw_decoder.c cw_decoder.h encoder.c encoder.h fft.c fft.h fpga.c fpga.h functions.c functions.h lcd.c lcd.h noise_reduction.c noise_reduction.h profiler.c profiler.h settings.c settings.h system_menu.c system_menu.h spec_analyzer.c spec_analyzer.h trx_manager.c trx_manager.h wm8731.c wm8731.h wifi.c wifi.h wire.c wire.h usbd_ua3reo.c usbd_ua3reo.h usbd_cat_if.c usbd_cat_if.h usbd_debug_if.c usbd_debug_if.h usbd_audio_if.c usbd_audio_if.h main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ../Inc/: main.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal_rcc_ex.h
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Inc/: main.h stm32f4xx_hal_conf.h stm32f4xx_it.h
    ../Src/: system_stm32f4xx.c
  group LCD
    ../Src/LCD/: xpt2046_spi.c xpt2046_spi.h fonts.h lcd_driver.c lcd_driver.h
  group USBDevice
    ../USBDevice/: usb_device.c usb_device.h usbd_conf.c usbd_conf.h usbd_core.c usbd_core.h usbd_ctlreq.c usbd_ctlreq.h usbd_def.h usbd_desc.c usbd_desc.h usbd_ioreq.c usbd_ioreq.h
software components: CMSIS:CORE 5.2.0, CMSIS:DSP 1.6.0
